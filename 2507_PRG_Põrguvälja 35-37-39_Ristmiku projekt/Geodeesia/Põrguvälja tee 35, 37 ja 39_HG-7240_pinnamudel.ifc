Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , ,]
File name: C:\Users\Anastassia\Desktop\Põrguvälja tee 35, 37 ja 39_HG-7240.ifc
Time: 2026-03-12T08:29:33
Author: Anastassia
Written by: ODA SDAI 24.6
Made in: Build

# IfcProject, xs
LongName: Põrguvälja tee 35, 37 ja 39_HG-7240_mudel_ifc
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, Põrguvälja tee 35, 37 ja 39_HG-7240_mudel_ifc
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
