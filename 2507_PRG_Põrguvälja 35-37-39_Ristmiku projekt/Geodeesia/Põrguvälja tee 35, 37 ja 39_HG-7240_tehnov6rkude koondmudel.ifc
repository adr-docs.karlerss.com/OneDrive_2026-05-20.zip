Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition[DesignTransferView]
File name: V2.ifc (Edited by Simplebim 10.1 SR4)
Time: 2026-03-04T15:22:57+02:00
Written by: IfcOpenShell 0.8.4
Made in: Bonsai 0.8.4
Authorization: Nobody

# IfcBuildingElementProxy, IfcBuildingElementProxy/Box002_Defintion Box002
In: My Storey
ePset_Simplebim - Assembly Level: Single

# IfcCableCarrierFitting: EN_Kaev, IfcBuildingElementProxy/Box001_Defintion Box001
In: My Storey
PredefinedType: USERDEFINED
mudeli_atribuutid - 04_Täpsusklass: Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011»,«Maa-ala plaan №HG-7240 ja Kaevude tabel_HG-7240 HADES GEODEESIA OÜ kuup. 17.02.2026» alusel; 03_Staatus: Olemasolev; 01_ID: 58; 02_Nimetus: SIDEKAEV ASS-103; 05_Märkused: Kõrgused EH2000 süsteemis. Koordinaadid L-Est 97 süsteemis.
ePset_Simplebim - Assembly Level: Single

# IfcCableCarrierSegment: EL_Toru (5)
In: My Storey
PredefinedType: USERDEFINED
ePset_Simplebim - Assembly Level: Single
mudeli_atribuutid - 03_Staatus: Olemasolev; 05_Märkused: Kõrgused EH2000 süsteemis. Koordinaadid L-Est 97 süsteemis.
Name | 02_Nimetus | 01_ID | 04_Täpsusklass
IfcBuildingElementProxy/Line029_Defintion Line029 | Kaitsetoru PL110-450N | 57 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №6176 OÜ GEOPLAN EESTI kuup. 06.04.2016» alusel
IfcBuildingElementProxy/Line031_Defintion Line031 | Kaitsetoru PL110-450N | 55 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №6176 OÜ GEOPLAN EESTI kuup. 06.04.2016» alusel
IfcBuildingElementProxy/Line030_Defintion Line030 | Kaitsetoru PL110-750N | 56 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №6176 OÜ GEOPLAN EESTI kuup. 06.04.2016» alusel
IfcBuildingElementProxy/Line040_Defintion Line040 | EL kaitsetoru | 54 | Eeldatav. Objekti plaaniline asukoht on modelleeritud teostusjoonise «Maa-ala plaan №HG-7240 HADES GEODEESIA OÜ kuup. 17.02.2026» alusel, kuid kõrguslik asukoht on antud tinglikult (1 meeter maapinnast madalamal
IfcBuildingElementProxy/Line041_Defintion Line041 | EL kaitsetoru | 53 | Eeldatav. Objekti plaaniline asukoht on modelleeritud teostusjoonise «Maa-ala plaan №HG-7240 HADES GEODEESIA OÜ kuup. 17.02.2026» alusel, kuid kõrguslik asukoht on antud tinglikult (1 meeter maapinnast madalamal

# IfcCableCarrierSegment: EN_Toru (12)
In: My Storey
PredefinedType: USERDEFINED
ePset_Simplebim - Assembly Level: Single
mudeli_atribuutid - 03_Staatus: Olemasolev; 05_Märkused: Kõrgused EH2000 süsteemis. Koordinaadid L-Est 97 süsteemis.
Name | 01_ID | 02_Nimetus | 04_Täpsusklass
IfcBuildingElementProxy/Line024_Defintion Line024 | 50 | SIDE | Eeldatav. Objekti plaaniline asukoht on modelleeritud teostusjoonise «Maa-ala plaan №HG-7240 HADES GEODEESIA OÜ kuup. 17.02.2026» alusel, kuid kõrguslik asukoht on antud tinglikult (1 meeter maapinnast madalamal
IfcBuildingElementProxy/Line021_Defintion Line021 | 45 | PEH 100 hulsstoru | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Line025_Defintion Line025 | 52 | SIDE | Eeldatav. Objekti plaaniline asukoht on modelleeritud teostusjoonise «Maa-ala plaan №HG-7240 HADES GEODEESIA OÜ kuup. 17.02.2026» alusel, kuid kõrguslik asukoht on antud tinglikult (1 meeter maapinnast madalamal
IfcBuildingElementProxy/Line028_Defintion Line028 | 49 | PEH 110 hulsstoru | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Line022_Defintion Line022 | 40 | PEH 110 hulsstoru | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Line027_Defintion Line027 | 41 | PEH 110 hulsstoru | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Line020_Defintion Line020 | 48 | PEH 110 hulsstoru | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Line026_Defintion Line026 | 46 | PEH 100 hulsstoru | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Tube225_Defintion Tube225 | 43 | üleminek PL100-PEH110 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Tube229_Defintion Tube229 | 44 | üleminek PL100-PEH110 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Tube231_Defintion Tube231 | 47 | üleminek PL100-PEH110 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel
IfcBuildingElementProxy/Tube227_Defintion Tube227 | 48 | üleminek PL100-PEH110 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №TJ - 859/01-11 OÜ GEOPLUS kuup. 31.01.2011» alusel

# IfcFireSuppressionTerminal: VK_Siiber (5)
In: My Storey
PredefinedType: USERDEFINED
ePset_Simplebim - Assembly Level: Single
mudeli_atribuutid - 03_Staatus: Olemasolev; 04_Täpsusklass: Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel; 05_Märkused: Kõrgused EH2000 süsteemis. Koordinaadid L-Est 97 süsteemis.
Name | 02_Nimetus | 01_ID
IfcBuildingElementProxy/Tube181_Defintion Tube181 | Maasiiber DN100 HAWLE | 35
IfcBuildingElementProxy/Tube185_Defintion Tube185 | Maasiiber DN200 HAWLE | 37
IfcBuildingElementProxy/Tube182_Defintion Tube182 | Maasiiber DN100 HAWLE | 36
IfcBuildingElementProxy/Tube184_Defintion Tube184 | Maasiiber DN100 HAWLE | 38
IfcBuildingElementProxy/Tube183_Defintion Tube183 | Maasiiber DN100 HAWLE | 39

# IfcFooting: EL_Kandur (4)
In: My Storey
PredefinedType: USERDEFINED
mudeli_atribuutid - 03_Staatus: Olemasolev; 02_Nimetus: Valgustipostide kann; 04_Täpsusklass: Eeldatav. Objekti plaaniline asukoht on modelleeritud teostusjoonise «Maa-ala plaan №HG-7240 HADES GEODEESIA OÜ kuup. 17.02.2026» alusel, kuid kõrguslik asukoht on antud tinglikult (1 meeter maapinnast madalamal; 05_Märkused: Kõrgused EH2000 süsteemis. Koordinaadid L-Est 97 süsteemis.
ePset_Simplebim - Assembly Level: Single
Name | 01_ID
IfcBuildingElementProxy/Cylinder080_Defintion Cylinder080 | 32
IfcBuildingElementProxy/Cylinder081_Defintion Cylinder081 | 33
IfcBuildingElementProxy/Cylinder079_Defintion Cylinder079 | 31
IfcBuildingElementProxy/Cylinder082_Defintion Cylinder082 | 34

# IfcPipeSegment: GV_Toru, IfcBuildingElementProxy/Line023_Defintion Line023
In: My Storey
PredefinedType: USERDEFINED
mudeli_atribuutid - 03_Staatus: Olemasolev; 01_ID: 25; 02_Nimetus: PE 100 GAASITORU 280x25.4; 04_Täpsusklass: Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №E-1220 OÜ GEOMETRIA. 2003» alusel; 05_Märkused: Kõrgused EH2000 süsteemis. Koordinaadid L-Est 97 süsteemis.
ePset_Simplebim - Assembly Level: Single

# IfcPipeSegment: VK_Toru (19)
In: My Storey
PredefinedType: USERDEFINED
mudeli_atribuutid - 03_Staatus: Olemasolev; 04_Täpsusklass: Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel; 05_Märkused: Kõrgused EH2000 süsteemis. Koordinaadid L-Est 97 süsteemis.
ePset_Simplebim - Assembly Level: Single
Name | 01_ID | 02_Nimetus
IfcBuildingElementProxy/Line004_Defintion Line004 | 28 | Veetoru PE De110
IfcBuildingElementProxy/Line008_Defintion Line008 | 22 | VK toru 400PRAGMA
IfcBuildingElementProxy/Line005_Defintion Line005 | 30 | Veetoru PE De110
IfcBuildingElementProxy/Line013_Defintion Line013 | 17 | VK toru 400PRAGMA
IfcBuildingElementProxy/Line015_Defintion Line015 | 12 | VK toru 160PVC
IfcBuildingElementProxy/Line016_Defintion Line016 | 14 | VK toru 280PE100
IfcBuildingElementProxy/Line017_Defintion Line017 | 15 | VK toru 280PE100
IfcBuildingElementProxy/Line007_Defintion Line007 | 23 | VK toru 400PRAGMA
IfcBuildingElementProxy/Line003_Defintion Line003 | 29 | Veetoru PE De110
IfcBuildingElementProxy/Line009_Defintion Line009 | 21 | VK toru 400PRAGMA
IfcBuildingElementProxy/Line011_Defintion Line011 | 19 | VK toru 400PRAGMA
IfcBuildingElementProxy/Line010_Defintion Line010 | 20 | VK toru 400PRAGMA
IfcBuildingElementProxy/Line014_Defintion Line014 | 13 | VK toru 160PVC
IfcBuildingElementProxy/Line012_Defintion Line012 | 18 | VK toru 400PRAGMA
IfcBuildingElementProxy/Line019_Defintion Line019 | 24 | VK toru 160PVC
IfcBuildingElementProxy/Line018_Defintion Line018 | 16 | VK toru 400PRAGMA
IfcBuildingElementProxy/Line001_Defintion Line001 | 25 | Veetoru De200 PE PN10
IfcBuildingElementProxy/Line002_Defintion Line002 | 26 | Veetoru PE De160
IfcBuildingElementProxy/Line006_Defintion Line006 | 27 | Veetoru PE De110

# IfcWasteTerminal: VK_Kaev (11)
In: My Storey
PredefinedType: USERDEFINED
mudeli_atribuutid - 03_Staatus: Olemasolev; 02_Nimetus: VK kaev; 05_Märkused: Kõrgused EH2000 süsteemis. Koordinaadid L-Est 97 süsteemis.
ePset_Simplebim - Assembly Level: Single
Name | 01_ID | 04_Täpsusklass | Toru 2 (Alt) 400PRAGMA | Kanalisatsioonikaev, Toru 1 (Alt) 400PRAGMA | Kanalisatsioonikaev, Põhi | Kanalisatsioonikaev, № | Kaas
IfcBuildingElementProxy/Cylinder041_Defintion Cylinder041 | 10 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel | 49.712 | 49.712 | 49.712 | K1-72 400/315 | 52.152
IfcBuildingElementProxy/Tube203_Defintion Tube203 | 8 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «Maa-ala plaan №HG-7240 ja Kaevude tabel_HG-7240 HADES GEODEESIA OÜ kuup. 17.02.2026» alusel |  |  | 50.36 | K1-70a 400/315 | 52.30 | Kanalisatsioonikaev - Toru 2 (Alt) 160PVC: 50.20
IfcBuildingElementProxy/Tube200_Defintion Tube200 | 7 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel | 49.912 | 49.912 | 49.912 | K1-70 400/315 | 51.992 | Kanalisatsioonikaev - Toru 3 (Alt) 160PVC: 50.142
IfcBuildingElementProxy/Tube206_Defintion Tube206 | 6 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel | 49.962 | 49.962 | 49.962 | K1-69 400/315 | 52.052
IfcBuildingElementProxy/Tube214_Defintion Tube214 | 9 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel | 49.772 | 49.772 | 49.772 | K1-71 800/500 | 51.992
IfcBuildingElementProxy/Tube217_Defintion Tube217 | 4 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel |  | 50.092 | 50.092 | K1-67 800/500 | 52.222 | Kanalisatsioonikaev - Toru 2 (Alt) 400PVC: 50.092
IfcBuildingElementProxy/Tube223_Defintion Tube223 | 2 | Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel | Survekanalisatsioonikaev - Toru 2 (Alt) 280PE100: 50.582; №: VRK1-1 800/500; MyProperty: 51.892; Põhi: 50.242; Toru 1 (Alt) 400PRAGMA: 50.292
IfcBuildingElementProxy/Cylinder039_Defintion Cylinder039 | 11 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel | 49.662 | 49.662 | 49.662 | K1-73 400/315 | 52.202
IfcBuildingElementProxy/Tube209_Defintion Tube209 | 5 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel | 50.022 | 50.022 | 50.022 | K1-68 400/315 | 52.222
IfcBuildingElementProxy/Tube212_Defintion Tube212 | 1 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel |  | 50.582 | 50.582 | K1-65 400/315 | 52.202 | Kanalisatsioonikaev - Toru 2 (Alt) 400PVC: 50.582
IfcBuildingElementProxy/Tube220_Defintion Tube220 | 3 | Täpne. Objekt on modelleeritud teostusdokumentatsiooni: «teostusjoonis №A70075 OÜ IVM GEO kuup. 16.07.2007» alusel |  | 50.152 | 50.152 | K1-66 800/500 | 51.622 | Kanalisatsioonikaev - Toru 2 (Alt) 160PVC: 50.392; Toru 3 (Alt) 400PRAGMA: 50.242
